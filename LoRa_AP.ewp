# IAR project LoRa_AP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x250
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ; ..\; ..\src\board; ..\src\sensors; ..\src\stm8l_stdlib\inc; ..\src\sx1278_stdlib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LoRa_AP.hex
  ILINK.IlinkOutputFile: LoRa_AP.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group board
    ../src/board/: atcmd_proc.c conf_eeprom.c lora_ack.c stm8_board.c stm8l15x_it.c timing_delay.c
    ../src/sensors/: crc-itu-t.c
  group stm8l_stdlib
    ../src/stm8l_stdlib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group sx1278_stdlib
    ../src/sx1278_stdlib/: radio.c sx1232-Misc.c sx1232.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1272.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
